# Repository andrastantos/anacron (continued)

## KiCad design boards/a1_low_end/a1_low_end.kicad_pcb (continued)

Parts:
C20: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U19: ESPRESSO; DIP-40_W15.24mm_Socket

Connections:
+5V: C20.1, U19.40 (VCC); also elsewhere on the board
/CPU_A0: U19.1 (A0); also elsewhere on the board
/CPU_A1: U19.2 (A1); also elsewhere on the board
/CPU_A2: U19.3 (A2); also elsewhere on the board
/CPU_A3: U19.4 (A3); also elsewhere on the board
/CPU_A4: U19.5 (A4); also elsewhere on the board
/CPU_A5: U19.6 (A5); also elsewhere on the board
/CPU_A6: U19.7 (A6); also elsewhere on the board
/CPU_A7: U19.8 (A7); also elsewhere on the board
/CPU_A8: U19.9 (A8); also elsewhere on the board
/CPU_A9: U19.10 (A9); also elsewhere on the board
/CPU_A10: U19.11 (A10); also elsewhere on the board
/CPU_D0: U19.12 (D0); also elsewhere on the board
/CPU_D1: U19.13 (D1); also elsewhere on the board
/CPU_D2: U19.14 (D2); also elsewhere on the board
/CPU_D3: U19.15 (D3); also elsewhere on the board
/CPU_D4: U19.16 (D4); also elsewhere on the board
/CPU_D5: U19.17 (D5); also elsewhere on the board
/CPU_D6: U19.18 (D6); also elsewhere on the board
/CPU_D7: U19.19 (D7); also elsewhere on the board
/CPU_DRQ0: U19.31 (DRQ_0); also elsewhere on the board
/CPU_DRQ1: U19.33 (DRQ_1); also elsewhere on the board
/CPU_DRQ2: U19.35 (DRQ_2); also elsewhere on the board
/CPU_DRQ3: U19.37 (DRQ_3); also elsewhere on the board
/CPU_TC: U19.39 (DMA_TC); also elsewhere on the board
/CPU_~CAS_0: U19.23 (~CAS_0); also elsewhere on the board
/CPU_~CAS_1: U19.24 (~CAS_1); also elsewhere on the board
/CPU_~DACK0: U19.32 (~DACK_0); also elsewhere on the board
/CPU_~DACK1: U19.34 (~DACK_1); also elsewhere on the board
/CPU_~DACK2: U19.36 (~DACK_2); also elsewhere on the board
/CPU_~DACK3: U19.38 (~DACK_3); also elsewhere on the board
/CPU_~INT: U19.30 (~INT); also elsewhere on the board
/CPU_~NREN: U19.25 (~NREN); also elsewhere on the board
/CPU_~RAS_A: U19.21 (~RAS_A); also elsewhere on the board
/CPU_~RAS_B: U19.22 (~RAS_B); also elsewhere on the board
/CPU_~WAIT: U19.27 (~WAIT); also elsewhere on the board
/CPU_~WE: U19.26 (~WE); also elsewhere on the board
GND: C20.2, U19.20 (GND); also elsewhere on the board
SYS_CLK: U19.28 (SYS_CLK); also elsewhere on the board
~RST: U19.29 (~RST); also elsewhere on the board

Parts:
C24, C25, C26: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C27, C28: 1uF; CP_Radial_D4.0mm_P2.00mm
C29: 4.7uF; CP_Radial_D4.0mm_P2.00mm
C30, C31: 220uF; CP_Radial_D7.5mm_P2.50mm
CMC1, CMC2, CMC3, CMC4: L_Ferrite_Coupled_Small; SCM2012FS
D6: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
F1: 0.5A; Fuse_BelFuse_0ZRE0005FF_L8.3mm_W3.8mm
FB1, FB2, FB4, FB5, FB6, FB7, FB8, FB9: FerriteBead_Small; L_Axial_L7.0mm_D3.3mm_P2.54mm_Vertical_Fastron_MICC
FB3: FerriteBead_Small; L_Axial_L5.3mm_D2.2mm_P7.62mm_Horizontal_Vishay_IM-1
J8, J11: SJ1-3535NG-BE; CUI_SJ1-3535NG-BE; PARTREV 1.0
J9: Conn_01x02; PinHeader_1x04_P2.54mm_Vertical
J10: HDMI_A; HDMI_A_Molex_208658-1001_Horizontal
JP2: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
JP7: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R10, R11, R14, R15: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R12, R13: 220k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R16, R17: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
TP1: TestPoint_Alt; TestPoint_Plated_Hole_D2.0mm
U22: DISCO; DIP-40_W15.24mm_Socket_LongPads
U23: A1_CODEC; DIP-32_W15.24mm_LongPads
X2: CXO_DIP14; Oscillator_DIP-14

Connections:
+5V: C24.1, C25.1, C26.1, D6.2 (A), JP2.1 (A), U22.40 (VCC), U23.32 (VCC_5), X2.1 (EN), X2.14 (Vcc); also elsewhere on the board
/BUF_A0: U22.11 (A0); also elsewhere on the board
/BUF_D0: U22.32 (D0); also elsewhere on the board
/BUF_D1: U22.33 (D1); also elsewhere on the board
/BUF_D2: U22.34 (D2); also elsewhere on the board
/BUF_D3: U22.35 (D3); also elsewhere on the board
/BUF_D4: U22.36 (D4); also elsewhere on the board
/BUF_D5: U22.37 (D5); also elsewhere on the board
/BUF_D6: U22.38 (D6); also elsewhere on the board
/BUF_D7: U22.39 (D7); also elsewhere on the board
/BUF_~WE: U22.27 (~WE); also elsewhere on the board
/CPU_DRQ0: U22.9 (DRQ); also elsewhere on the board
/CPU_~CAS_0: U22.24 (~CAS_0); also elsewhere on the board
/CPU_~CAS_1: U22.25 (~CAS_1); also elsewhere on the board
/CPU_~DACK0: U22.10 (~DACK); also elsewhere on the board
/CPU_~INT: U22.30 (~INT); also elsewhere on the board
/GFX/AUDIO_SDATA_IN: U22.22 (AUDIO_SDATA_IN), U23.29 (ADCOUT)
/GFX/AUDIO_SDATA_OUT: U22.21 (AUDIO_SDATA_OUT), U23.30 (DACIN)
/GFX/AUDIO_SFRM: U22.19 (AUDIO_SFRM), U23.27 (FS)
/GFX/CODEC_V3P3: JP2.3 (B), R12.1, R13.1, U23.5 (3P3_OUT)
/GFX/HP_DET: J11.4, R12.2, U23.24 (LLIN/GPIO2)
/GFX/LINE_IN_DET: J8.4, R13.2, U23.25 (RLIN/GPIO3)
/GFX/TMDS_CLK+: CMC4.1, U22.7 (TMDS_C+)
/GFX/TMDS_CLK-: CMC4.4, U22.8 (TMDS_C-)
/GFX/TMDS_D0+: CMC3.1, U22.5 (TMDS_D0+)
/GFX/TMDS_D0-: CMC3.4, U22.6 (TMDS_D0-)
/GFX/TMDS_D1+: CMC2.1, U22.3 (TMDS_D1+)
/GFX/TMDS_D1-: CMC2.4, U22.4 (TMDS_D1-)
/GFX/TMDS_D2+: CMC1.1, U22.1 (TMDS_D2+)
/GFX/TMDS_D2-: CMC1.4, U22.2 (TMDS_D2-)
/I2C_SCL: U23.3 (SDIO); also elsewhere on the board
/I2C_SDA: U23.2 (SCLK); also elsewhere on the board
/VIDEO_DDC_SCL: FB4.1; also elsewhere on the board
/VIDEO_DDC_SDA: FB6.1; also elsewhere on the board
/VIDEO_HPD: FB5.1; also elsewhere on the board
/~GFX_SEL: U22.26 (~REG_SEL)
GND: C24.2, C25.2, C26.2, C29.2, J10.2 (D2S), J10.5 (D1S), J10.8 (D0S), J10.11 (CKS), J10.17 (GND), J10.SH, JP7.1 (A), R16.1, R17.1, U22.20 (GND), U23.4 (GND), X2.7 (GND); also elsewhere on the board
GNDA: J8.1, J11.1, JP7.2 (B), R10.2, R11.2, R14.2, R15.2, U23.10 (AGND), U23.16 (AGND), U23.17 (AGND), U23.23 (AGND), U23.26 (AGND)
unnamed: C27.2, FB1.2, R10.1
unnamed: C28.2, FB2.2, R11.1
unnamed: C30.2, FB7.2, R14.1
unnamed: C31.2, FB8.2, R15.1
unnamed: D6.1 (K), F1.2
unnamed: F1.1, FB9.2
unnamed: FB1.1, J8.2
unnamed: FB2.1, J8.3
unnamed: FB7.1, J11.2
unnamed: FB8.1, J11.3
unnamed: J9.1, J9.2, U23.12 (LSPKOUT)
unnamed: J9.3, J9.4, U23.11 (RSPKOUT)
unnamed: FB9.1, J10.18 (+5V)
unnamed: J10.13 (CEC), R16.2
unnamed: CMC4.2, J10.10 (CK+)
unnamed: CMC4.3, J10.12 (CK-)
unnamed: CMC3.2, J10.7 (D0+)
unnamed: CMC3.3, J10.9 (D0-)
unnamed: CMC2.2, J10.4 (D1+)
unnamed: CMC2.3, J10.6 (D1-)
unnamed: CMC1.2, J10.1 (D2+)
unnamed: CMC1.3, J10.3 (D2-)
unnamed: FB5.2, J10.19 (HPD)
unnamed: FB4.2, J10.15 (SCL)
unnamed: FB6.2, J10.16 (SDA)
unnamed: J10.14 (UTILITY), R17.2
unnamed: FB3.1, JP2.2 (C)
unnamed: U22.18 (VIDEO_CLK), X2.8 (OUT)
unnamed: TP1.1, U23.1 (CSB/GPIO1)
unnamed: C27.1, U23.7 (LAUXIN)
unnamed: C30.1, U23.15 (LHP)
unnamed: C28.1, U23.6 (RAUXIN)
unnamed: C31.1, U23.14 (RHP)
unnamed: C29.1, FB3.2, U23.13 (V_SPKR)
SYS_CLK: U22.29 (SYS_CLK), U23.28 (BCLK), U23.31 (MCLK); also elsewhere on the board
~RST: U22.28 (~RST); also elsewhere on the board

Notes on the sheet:
TMDS output is quite a bit dicey on UNIC. The power diodes add too much capacitive load and limit operations to maybe 250...300Mbps. That might be sufficient for VGA resolution but not for XGA.
GND and GNDA are tied inside CODEC

Parts:
BT1: CR2032 holder; BatteryHolder_Keystone_103_1x20mm
C32, C33, C34, C35, C36, C37, C38, C66, C67: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
FB10, FB11, FB12, FB13, FB14: FerriteBead_Small; L_Axial_L7.0mm_D3.3mm_P2.54mm_Vertical_Fastron_MICC
J12: DE9_Plug; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Hou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
J13: Micro_SD_Card; GCT_MEM2052-00-195-00-A_REVA
R18, R19: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R20, R21: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN7, RN8, RN9: 10k; R_Array_SIP5
U24: MAX232; DIP-16_W7.62mm_LongPads
U25: MIO; DIP-40_W15.24mm_Socket
U26: DS1307+; DIP-8_W7.62mm
U29: L78L33ABZ-AP; TO-92_Inline
X3: 24MHz; Oscillator_DIP-14
Y1: 32768Hz; Crystal_AT310_D3.0mm_L10.0mm_Horizontal_1EP_style2

Connections:
+5V: C34.1, C36.1, C37.1, C38.1, C66.1, R21.2, RN7.1 (common), U24.16 (VCC), U25.40 (VCC), U26.8 (VCC), U29.3 (VI), X3.1 (EN), X3.14 (Vcc); also elsewhere on the board
+BATT: BT1.1 (+), U26.3 (VBAT)
/BUF_A0: U25.31 (A0); also elsewhere on the board
/BUF_D0: U25.32 (D0); also elsewhere on the board
/BUF_D1: U25.33 (D1); also elsewhere on the board
/BUF_D2: U25.34 (D2); also elsewhere on the board
/BUF_D3: U25.35 (D3); also elsewhere on the board
/BUF_D4: U25.36 (D4); also elsewhere on the board
/BUF_D5: U25.37 (D5); also elsewhere on the board
/BUF_D6: U25.38 (D6); also elsewhere on the board
/BUF_D7: U25.39 (D7); also elsewhere on the board
/BUF_~WE: U25.27 (~WE); also elsewhere on the board
/CPU_DRQ0: U25.23 (DRQ); also elsewhere on the board
/CPU_TC: U25.25 (~DMA_TC); also elsewhere on the board
/CPU_~DACK0: U25.24 (~DACK); also elsewhere on the board
/CPU_~INT: U25.30 (~INT); also elsewhere on the board
/I2C_SCL: RN7.5 (R4), U25.14 (PA7_I2CSCL2), U26.6 (SCL); also elsewhere on the board
/I2C_SDA: RN7.4 (R3), U25.13 (PA6_I2CSDA2), U26.5 (SDA); also elsewhere on the board
/I2C_~INT: R21.1, U26.7 (SQW/OUT); also elsewhere on the board
/MIO/SD_CLK: J13.5 (CLK), RN8.4 (R3), U25.22 (PB5_SDclk)
/MIO/SD_CMD: J13.3 (CMD), RN8.5 (R4), U25.21 (PB4_SDcmd)
/MIO/SD_D0: J13.7 (DAT0), RN9.2 (R1), U25.15 (PB0_SDd0)
/MIO/SD_D1: J13.8 (DAT1), RN9.3 (R2), U25.16 (PB1_SDd1)
/MIO/SD_D2: J13.1 (DAT2), RN9.4 (R3), U25.17 (PB2_SDd2)
/MIO/SD_D3: J13.2 (DAT3/CD), RN9.5 (R4), U25.19 (PB3_SDd3)
/MIO/SER_CTS: R19.1, U25.10 (PA3_CTS_~SPICS)
/MIO/SER_RTS: U24.10 (T2IN), U25.9 (PA2_RTS_SPIMOSI)
/MIO/SER_RXD: R18.1, U25.8 (PA1_RXD)
/MIO/SER_TXD: U24.11 (T1IN), U25.7 (PA0_TXD)
/MIO/USB_A_D+: U25.1 (PC0_USBa_D+); also elsewhere on the board
/MIO/USB_A_D-: U25.2 (PC1_USBa_D-); also elsewhere on the board
/MIO/USB_B_D+: U25.3 (PC2_USBb_D+); also elsewhere on the board
/MIO/USB_B_D-: U25.4 (PC3_USBb_D-); also elsewhere on the board
/MIO/USB_CLK: U25.28 (USB_CLK), X3.8 (OUT)
/MIO/USB_C_D+: U25.5 (PC4_USBc_D+); also elsewhere on the board
/MIO/USB_C_D-: U25.6 (PC5_USBc_D-); also elsewhere on the board
/MIO/VCC_SD: C67.1, J13.4 (VDD), R20.2, RN8.1 (common), RN9.1 (common), U29.1 (VO)
/VIDEO_DDC_SCL: RN7.3 (R2), U25.12 (PA5_SPICLK_I2CSCL1); also elsewhere on the board
/VIDEO_DDC_SDA: RN7.2 (R1), U25.11 (PA4_SPIMISO_I2CSDA1); also elsewhere on the board
/~MIO_SEL: U25.26 (~CS)
/~SD_CARD_DET: J13.9 (DET), R20.1; also elsewhere on the board
GND: BT1.2 (-), C35.2, C36.2, C37.2, C38.2, C66.2, C67.2, J12.5, J13.6 (VSS), J13.10 (SHIELD), U24.15 (GND), U25.20 (GND), U26.4 (GND), U29.2 (GND), X3.7 (GND), Y1.3; also elsewhere on the board
unnamed: FB10.2, J12.4
unnamed: FB11.2, J12.3
unnamed: FB12.2, J12.7
unnamed: FB13.2, J12.2
unnamed: FB14.2, J12.8
unnamed: C32.1, U24.1 (C1+)
unnamed: C32.2, U24.3 (C1-)
unnamed: C33.1, U24.4 (C2+)
unnamed: C33.2, U24.5 (C2-)
unnamed: FB13.1, U24.13 (R1IN)
unnamed: R18.2, U24.12 (R1OUT)
unnamed: FB14.1, U24.8 (R2IN)
unnamed: R19.2, U24.9 (R2OUT)
unnamed: FB11.1, U24.14 (T1OUT)
unnamed: FB12.1, U24.7 (T2OUT)
unnamed: C34.2, FB10.1, U24.2 (VS+)
unnamed: C35.1, U24.6 (VS-)
unnamed: U26.1 (X1), Y1.2
unnamed: U26.2 (X2), Y1.1
SYS_CLK: U25.18 (SYS_CLK); also elsewhere on the board
~RST: U25.29 (~RST); also elsewhere on the board

Notes on the sheet:
One could use the SIO10N268 ($10) which gives four UARTs and an FDD controller and it's in active production still. https://ww1.microchip.com/downloads/aemDocuments/documents/OTH/ProductDocuments/DataSheets/00001819A.pdf
TODO: check connector depth!
DTR: connected to +9V for mouse support

Board: 4 copper layers, 243.8 x 204.5 mm, 183 parts (0 on the bottom side), 249 nets.

## Commit log

2024-07-02 Fixed address hold for broken bursts.
2024-07-02 Implemented nWE generation.
2024-07-02 Output data is also generated now for writes.
2024-07-02 Wait-state change also breaks bursts.
2024-07-02 Reworked burst break logic.
    It should really be based on top address bits and address type
    instead of trying to be clever about it.
2024-07-02 Address data on data-pins during RAS phase.
2024-07-02 One internal WS transactions seem to work now.
    Still no higher internal WSs, let alone external ones.
2024-07-03 Reordered interface members to be a little more logical.
2024-07-03 Some progress towards external WS handling.
2024-07-08 Started documenting 16-bit wider data-bus idea.
2024-07-08 More musings on memory cycles and bandwidths.
2024-07-09 More next-gen musings.
2024-12-16 Picked up thinking about the new bus-interface.
2025-01-28 Not sure what changed here. But some changes to LAN module.
2025-01-28 Found some net naming errors. Fixed.
2025-01-28 Started low-end (DMA graphics) motherboard.
    This is just a fun exercise, probably won't get far. It nevertheless seems to match the Acorn A3000 in chip count, though not on memory bandwidth. Of course they use PLCC packages with many more pins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
    have the option to.
2025-01-28 Not sure what changed in the libs.
2025-01-28 More musings around memory interfaces. This time SDRAM.
    I think all this is idle talk though, I'm going to stick with the
    8/16-bit interface and go finish that.
2025-01-28 Doesn't seem like much changed here...
