File: boards/a1_micro_atx/isa.kicad_sch (KiCad schematic)
At the start: 22 parts, among them J18 Bus_ISA_8bit, J19 Bus_ISA_8bit, J20 Bus_ISA_16bit, J21 Bus_ISA_16bit, U30 74AHCT245, U31 74AHCT14, U32 74AHCT139, U33 4075, U37 74AHCT245, U38 74HCT153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

Commit message: Found some net naming errors. Fixed.
