# Repository andrastantos/anacron

## KiCad design boards/a1_low_end/a1_low_end.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C72, C73: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C7: 10nF; C_Disc_D4.7mm_W2.5mm_P5.00mm; not fitted
D1, D2: LED; LED_D5.0mm
D3: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D4: D_Schottky; D_A-405_P7.62mm_Horizontal
J1, J2, J3, J4, J22, J23, J24: Conn_01x01; MountingHole_4.3mm_M4_DIN965_Pad
J5: Conn_01x10
J6: Jack-DC; BarrelJack_CUI_PJ-102AH_Horizontal
J17: Conn_01x14
J19: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
JP1, JP6: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R6, R7, R8, R36: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3, R4, R5, R9, R29: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN1, RN2: 10k; R_Array_SIP5
RN3, RN4, RN5: 10k; R_Array_SIP9
RN6: 10k; R_Array_SIP9; not fitted
SW2, SW4: SW_Push; PinHeader_1x02_P2.54mm_Vertical
SW3, SW5: SW_Push; SW_PUSH_6mm
U1: 74LS08; DIP-14_W7.62mm_LongPads
U2: 74LS86; DIP-14_W7.62mm_LongPads
U3: 74LS00; DIP-14_W7.62mm_LongPads
U4: 74LS273; DIP-20_W7.62mm_LongPads
U5, U13, U16, U17, U18: 74LS574; DIP-20_W7.62mm_LongPads
U6: 74LS139; DIP-16_W7.62mm_LongPads
U7: 74LS14; DIP-14_W7.62mm_LongPads
U8: 74LS126; DIP-14_W7.62mm_LongPads
U9: 74LS138
U10: 74LS145
U11: SST39SF040; DIP-32_W15.24mm_Socket_LongPads
U12: A1_POWER
U14, U15: 74AHCT245; DIP-20_W7.62mm_LongPads
U40: L78L05_TO92; TO-92_Inline
U43: ATtiny25-20P; DIP-8_W7.62mm_LongPads
X1: 8MHz; Oscillator_DIP-14

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C16.1, C17.1, C18.1, C19.1, D3.2 (A), R2.1, R5.1, R7.1, RN1.1 (common), RN3.1 (common), RN4.1 (common), RN5.1 (common), U1.14 (VCC), U2.9, U2.12, U2.14 (VCC), U3.14 (VCC), U4.20 (VCC), U5.20 (VCC), U6.16 (VCC), U7.14 (VCC), U8.14 (VCC), U9.6 (E3), U9.16 (VCC), U10.16 (VCC), U11.32 (VCC), U12.1 (VOUT), U12.2 (VOUT), U12.3 (VOUT), U12.4 (VOUT), U13.20 (VCC), U14.20 (VCC), U15.1 (A->B), U15.20 (VCC), U16.20 (VCC), U17.20 (VCC), U18.20 (VCC), X1.1 (EN), X1.14 (Vcc); also elsewhere on the board
+5V_STB: C73.1, JP6.2 (B), R36.1, U40.1 (VO), U43.8 (VCC)
/BOOT SELECT: J19.2, RN5.2 (R1), U13.2 (D0)
/BUF_A0: U3.2, U11.12 (A0), U15.8 (A6); also elsewhere on the board
/BUF_A1: U11.11 (A1), U16.12 (Q7)
/BUF_A2: U11.10 (A2), U16.19 (Q0)
/BUF_A3: U11.9 (A3), U16.13 (Q6)
/BUF_A4: U11.8 (A4), U16.18 (Q1)
/BUF_A5: U11.7 (A5), U16.14 (Q5)
/BUF_A6: U11.6 (A6), U16.17 (Q2)
/BUF_A7: U11.5 (A7), U16.15 (Q4)
/BUF_A8: U11.27 (A8), U16.16 (Q3)
/BUF_A9: U11.26 (A9), U15.3 (A1)
/BUF_A10: U11.23 (A10), U15.4 (A2)
/BUF_A11: U9.1 (A0), U11.25 (A11), U15.5 (A3)
/BUF_A12: U9.2 (A1), U11.4 (A12), U18.12 (Q7)
/BUF_A13: U9.3 (A2), U11.28 (A13), U18.19 (Q0)
/BUF_A14: U11.29 (A14), U18.13 (Q6)
/BUF_A15: U11.3 (A15), U18.18 (Q1)
/BUF_A16: U11.2 (A16), U18.14 (Q5)
/BUF_A17: U11.30 (A17), U18.17 (Q2)
/BUF_A18: U11.1 (A18), U18.15 (Q4)
/BUF_A19: U18.16 (Q3)
/BUF_A20: U17.12 (Q7)
/BUF_A21: U6.2 (A0), U17.13 (Q6)
/BUF_A22: U6.3 (A1), U17.14 (Q5)
/BUF_CAS: U3.3, U3.4, U16.11 (Cp)
/BUF_D0: RN6.2 (R1), U4.8 (D3), U5.12 (Q7), U11.13 (D0), U13.12 (Q7), U14.7 (A5); also elsewhere on the board
/BUF_D1: RN6.3 (R2), U4.13 (D4), U5.13 (Q6), U11.14 (D1), U13.13 (Q6), U14.8 (A6); also elsewhere on the board
/BUF_D2: RN6.4 (R3), U4.7 (D2), U5.14 (Q5), U11.15 (D2), U13.14 (Q5), U14.9 (A7); also elsewhere on the board
/BUF_D3: RN6.5 (R4), U4.14 (D5), U5.15 (Q4), U11.17 (D3), U13.15 (Q4), U14.3 (A1); also elsewhere on the board
/BUF_D4: RN6.6 (R5), U4.4 (D1), U5.16 (Q3), U11.18 (D4), U13.16 (Q3), U14.2 (A0); also elsewhere on the board
/BUF_D5: RN6.7 (R6), U4.17 (D6), U5.17 (Q2), U11.19 (D5), U13.17 (Q2), U14.4 (A2); also elsewhere on the board
/BUF_D6: RN6.8 (R7), U4.3 (D0), U5.18 (Q1), U11.20 (D6), U13.18 (Q1), U14.5 (A3); also elsewhere on the board
/BUF_D7: RN6.9 (R8), U4.18 (D7), U5.19 (Q0), U11.21 (D7), U13.19 (Q0), U14.6 (A4); also elsewhere on the board
/BUF_DIR: U2.3, U14.1 (A->B)
/BUF_NREN: U2.8, U3.5, U5.11 (Cp), U7.10, U13.11 (Cp), U17.11 (Cp), U18.11 (Cp)
/BUF_TC: U15.2 (A0)
/BUF_~CAS: U3.1, U15.7 (A5)
/BUF_~EN: U1.3, U14.19 (CE)
/BUF_~NREN: U2.10, U7.11, U15.9 (A7)
/BUF_~RD: U7.12, U11.24 (OE)
/BUF_~WE: U2.2, U7.13, U11.31 (PGM), U15.6 (A4); also elsewhere on the board
/CPU_A0: U16.9 (D7), U18.9 (D7); also elsewhere on the board
/CPU_A1: U16.2 (D0), U18.2 (D0); also elsewhere on the board
/CPU_A2: U16.8 (D6), U18.8 (D6); also elsewhere on the board
/CPU_A3: U16.3 (D1), U18.3 (D1); also elsewhere on the board
/CPU_A4: U16.7 (D5), U18.7 (D5); also elsewhere on the board
/CPU_A5: U16.4 (D2), U18.4 (D2); also elsewhere on the board
/CPU_A6: U16.6 (D4), U18.6 (D4); also elsewhere on the board
/CPU_A7: U16.5 (D3), U18.5 (D3); also elsewhere on the board
/CPU_A8: U15.17 (B1), U17.9 (D7); also elsewhere on the board
/CPU_A9: U15.16 (B2), U17.8 (D6); also elsewhere on the board
/CPU_A10: U15.15 (B3), U17.7 (D5); also elsewhere on the board
/CPU_D0: U14.13 (B5); also elsewhere on the board
/CPU_D1: U14.12 (B6); also elsewhere on the board
/CPU_D2: U14.11 (B7); also elsewhere on the board
/CPU_D3: U14.17 (B1); also elsewhere on the board
/CPU_D4: U14.18 (B0); also elsewhere on the board
/CPU_D5: U14.16 (B2); also elsewhere on the board
/CPU_D6: U14.15 (B3); also elsewhere on the board
/CPU_D7: U14.14 (B4); also elsewhere on the board
/CPU_DACK: U2.1, U2.11
/CPU_DRQ0: RN2.5 (R4); also elsewhere on the board
/CPU_DRQ1: RN2.4 (R3); also elsewhere on the board
/CPU_DRQ2: RN2.3 (R2); also elsewhere on the board
/CPU_DRQ3: RN2.2 (R1); also elsewhere on the board
/CPU_TC: R1.1, U15.18 (B0); also elsewhere on the board
/CPU_~CAS_0: RN3.5 (R4), U15.12 (B6); also elsewhere on the board
/CPU_~CAS_1: RN3.6 (R5), U15.13 (B5); also elsewhere on the board
/CPU_~DACK0: RN1.5 (R4), U1.13; also elsewhere on the board
/CPU_~DACK1: RN1.4 (R3), U1.12; also elsewhere on the board
/CPU_~DACK2: RN1.3 (R2), U1.10; also elsewhere on the board
/CPU_~DACK3: RN1.2 (R1), U1.9; also elsewhere on the board
/CPU_~DACK: U1.2, U1.6, U2.13
/CPU_~INT: D4.2 (A), R2.2; also elsewhere on the board
/CPU_~NREN: RN3.7 (R6), U1.1, U15.11 (B7); also elsewhere on the board
/CPU_~RAS_A: RN3.3 (R2); also elsewhere on the board
/CPU_~RAS_B: RN3.4 (R3); also elsewhere on the board
/CPU_~WAIT: RN3.9 (R8); also elsewhere on the board
/CPU_~WE: RN3.8 (R7), U15.14 (B4); also elsewhere on the board
/EXT_~INT: RN5.3 (R2), U3.12, U13.3 (D1)
/I2C_SCL: U43.7 (PB2); also elsewhere on the board
/I2C_SDA: U43.5 (AREF/PB0); also elsewhere on the board
/I2C_~INT: RN5.5 (R4), U3.10, U13.5 (D3), U43.6 (PB1); also elsewhere on the board
/KBD_ACT_LED: R3.2, U4.6 (Q2)
/KBD_CAPS_LED: R29.2, U4.2 (Q0)
/KBD_COL_0: J5.3, RN4.2 (R1), U5.2 (D0)
/KBD_COL_1: J5.4, RN4.3 (R2), U5.3 (D1)
/KBD_COL_2: J5.5, RN4.4 (R3), U5.4 (D2)
/KBD_COL_3: J5.6, RN4.5 (R4), U5.5 (D3)
/KBD_COL_4: J5.7, RN4.6 (R5), U5.6 (D4)
/KBD_COL_5: J5.8, RN4.7 (R6), U5.7 (D5)
/KBD_COL_6: J5.9, RN4.8 (R7), U5.8 (D6)
/KBD_COL_7: J5.10, RN4.9 (R8), U5.9 (D7)
/KBD_COL_8: J5.2, RN5.8 (R7), U13.8 (D6)
/KBD_COL_9: J5.1, RN5.9 (R8), U13.9 (D7)
/KBD_NUM_LED: R9.2, U4.5 (Q1)
/LAN_~INT: RN5.4 (R3), U3.9, U13.4 (D2); also elsewhere on the board
/PG: JP1.1 (A), U12.12 (PG)
/PWR_IN: C72.1, D3.1 (K), J6.1, U12.6 (VIN), U12.7 (VIN), U40.3 (VI)
/PWR_ON: JP6.1 (A), R6.1, U12.9 (EN), U43.2 (XTAL1/PB3)
/VIDEO_HPD: RN5.6 (R5), U13.6 (D4); also elsewhere on the board
/~EXT_SEL: U6.5 (O1)
/~IO_SEL: U6.6 (O2), U9.4 (E1)
/~LAN_SEL: U6.7 (O3); also elsewhere on the board
/~MRST: JP1.2 (B), R7.2, SW2.2, SW3.2, U7.3
/~NR_DECODE_EN: U3.6, U6.1 (E)
/~ROM0_SEL: U6.4 (O0), U11.22 (CE)
/~SD_CARD_DET: RN5.7 (R6), U13.7 (D5); also elsewhere on the board
/~SYS_GPIO0_SEL: U4.11 (Cp), U9.14 (O1)
/~SYS_GPIO1_SEL: U9.13 (O2), U13.1 (OE)
/~SYS_GPIO2_SEL: U5.1 (OE), U9.12 (O3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C72.2, C73.2, D1.1 (K), D2.1 (K), J1.1, J2.1, J3.1, J4.1, J6.2, J17.1, J19.1, J22.1, J23.1, J24.1, R1.2, R6.2, RN2.1 (common), RN6.1 (common), SW2.1, SW3.1, SW4.1, SW5.1, U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.10 (GND), U5.10 (GND), U6.8 (GND), U7.7 (GND), U8.7 (GND), U9.5 (E2), U9.8 (GND), U10.8 (GND), U11.16 (GND), U12.5 (GND), U13.10 (GND), U14.10 (GND), U15.10 (GND), U15.19 (CE), U16.1 (OE), U16.10 (GND), U17.1 (OE), U17.10 (GND), U18.1 (OE), U18.10 (GND), U40.2 (GND), U43.4 (GND), X1.7 (GND); also elsewhere on the board
unnamed: C15.1, R8.2, U7.5
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R5.2
unnamed: D4.1 (K), U7.2
unnamed: J17.5, U10.1 (Q0)
unnamed: J17.6, U10.2 (Q1)
unnamed: J17.7, U10.3 (Q2)
unnamed: J17.8, U10.4 (Q3)
unnamed: J17.9, U10.5 (Q4)
unnamed: J17.10, U10.6 (Q5)
unnamed: J17.11, U10.7 (Q6)
unnamed: J17.12, U10.9 (Q7)
unnamed: J17.13, U10.10 (Q8)
unnamed: J17.14, U10.11 (Q9)
unnamed: J17.2, R29.1
unnamed: J17.3, R9.1
unnamed: J17.4, R3.1
unnamed: R8.1, U7.4
unnamed: U1.5, U1.8
unnamed: U1.4, U1.11
unnamed: U3.8, U7.9
unnamed: U3.11, U7.1
unnamed: U3.13, U7.8
unnamed: R4.1, U4.19 (Q7)
unnamed: U4.9 (Q3), U10.15 (P0)
unnamed: U4.12 (Q4), U10.14 (P1)
unnamed: U4.15 (Q5), U10.13 (P2)
unnamed: U4.16 (Q6), U10.12 (P3)
unnamed: C7.1, U12.8 (SS/TR)
unnamed: R36.2, SW4.2, SW5.2, U43.1 (~RESET/PB5)
SYS_CLK: X1.8 (OUT); also elsewhere on the board
~RST: U4.1 (~Mr), U7.6, U43.3 (XTAL2/PB4); also elsewhere on the board

Notes on the sheet:
Primary power
Reset generation
Always on domain
Mounting holes
PWR SWITCH
TODO: consider replacing '273-s with '574 ones. They seem to have a more forgiving pinout.
POWER BTN
PWR LED
TODO: check all bypass capacitors: do we have enough for everybody?
RESET BTN
ACTIVITY LED
We use BUF data, but buffer direction is fine. We do that to support both direct capture of DMAs as well as allow for I/O operations. To understand the DMA busts though, we connect CPU-side CAS signals.

Parts:
C39, C40: 22pF; C_Disc_D3.4mm_W2.1mm_P2.50mm
C41, C42: 0.1uF; C_Disc_D3.4mm_W2.1mm_P2.50mm
C43: 10u; CP_Radial_D4.0mm_P2.00mm
J14: ARJM11D7-009-AB-EW2
R22: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R23, R24: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R25, R26, R27, R28: 49.9; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U27: KSZ8851-11MLL; DIP-32_W15.24mm_LongPads
Y2: 25MHz; Crystal_HC49-U_Vertical

Connections:
+5V: R22.2, U27.32 (VCC); also elsewhere on the board
/BUF_A0: U27.15 (CMD); also elsewhere on the board
/BUF_D0: U27.9 (D7); also elsewhere on the board
/BUF_D1: U27.8 (D6); also elsewhere on the board
/BUF_D2: U27.7 (D5); also elsewhere on the board
/BUF_D3: U27.6 (D4); also elsewhere on the board
/BUF_D4: U27.5 (D3); also elsewhere on the board
/BUF_D5: U27.4 (D2); also elsewhere on the board
/BUF_D6: U27.3 (D1); also elsewhere on the board
/BUF_D7: U27.2 (D0); also elsewhere on the board
/BUF_~WE: U27.14 (~WE); also elsewhere on the board
/ETH/ETH_RX+: J14.R3 (RD+), R25.2, U27.26 (RXP1)
/ETH/ETH_RX-: J14.R6 (RD-), R26.2, U27.27 (RXM1)
/ETH/ETH_TX+: J14.R1 (TD+), R27.2, U27.29 (TXP1)
/ETH/ETH_TX-: J14.R2 (TD-), R28.2, U27.30 (TXM1)
/LAN_~INT: R22.1, U27.13 (~INTR); also elsewhere on the board
/~LAN_SEL: U27.17 (~CS); also elsewhere on the board
GND: C39.2, C40.2, C41.2, C42.2, C43.2, J14.R8, J14.SH, U27.16 (GND), U27.19 (GND), U27.20 (GND), U27.24 (GND), U27.25 (GND), U27.28 (GND), U27.31 (GND); also elsewhere on the board
unnamed: C41.1, R25.1, R26.1
unnamed: C42.1, R27.1, R28.1
unnamed: J14.L1, R23.2
unnamed: J14.L3, R24.2
unnamed: C43.1, J14.R4 (TCT), J14.R5 (RCT), U27.22 (VDD3P3_A)
unnamed: R23.1, U27.11 (P1LED0)
unnamed: R24.1, U27.10 (P1LED1)
unnamed: J14.L2, J14.L4, U27.1 (V3P3)
unnamed: C40.1, U27.21 (XTAL1), Y2.2
unnamed: C39.1, U27.23 (XTAL2), Y2.1
~RST: U27.18 (~RST); also elsewhere on the board

Parts:
C69, C71: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
J18: Conn_02x25_Row_Letter_First

Connections:
+5V: C69.1, C71.1, J18.a1, J18.b1; also elsewhere on the board
GND: C69.2, C71.2, J18.a2, J18.a16, J18.a25, J18.b7, J18.b13, J18.b19, J18.b25; also elsewhere on the board

Parts:
C51, C52, C53: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U21: SIMM-30x2; SIMM-30x2_VERT

Connections:
+5V: C51.1, C52.1, C53.1, U21.A1 (VCC), U21.A24 (A11), U21.A28 (~CASP), U21.A30 (VCC), U21.B1 (VCC), U21.B24 (A11), U21.B28 (~CASP), U21.B30 (VCC); also elsewhere on the board
/CPU_~CAS_0: U21.B2 (~CAS); also elsewhere on the board
/CPU_~CAS_1: U21.A2 (~CAS); also elsewhere on the board
/CPU_~RAS_B: U21.A27 (~RAS), U21.B27 (~RAS); also elsewhere on the board
/CPU_~WE: U21.A21 (~WE), U21.B21 (~WE); also elsewhere on the board
/GFX_D0: U21.A3 (DQ0), U21.B3 (DQ0)
/GFX_D1: U21.A6 (DQ1), U21.B6 (DQ1)
/GFX_D2: U21.A10 (DQ2), U21.B10 (DQ2)
/GFX_D3: U21.A13 (DQ3), U21.B13 (DQ3)
/GFX_D4: U21.A16 (DQ4), U21.B16 (DQ4)
/GFX_D5: U21.A20 (DQ5), U21.B20 (DQ5)
/GFX_D6: U21.A23 (DQ6), U21.B23 (DQ6)
/GFX_D7: U21.A25 (DQ7), U21.B25 (DQ7)
/RAM_BANK1/A0: U21.A4 (A0), U21.B4 (A0)
/RAM_BANK1/A1: U21.A5 (A1), U21.B5 (A1)
/RAM_BANK1/A2: U21.A7 (A2), U21.B7 (A2)
/RAM_BANK1/A3: U21.A8 (A3), U21.B8 (A3)
/RAM_BANK1/A4: U21.A11 (A4), U21.B11 (A4)
/RAM_BANK1/A5: U21.A12 (A5), U21.B12 (A5)
/RAM_BANK1/A6: U21.A14 (A6), U21.B14 (A6)
/RAM_BANK1/A7: U21.A15 (A7), U21.B15 (A7)
/RAM_BANK1/A8: U21.A17 (A8), U21.B17 (A8)
/RAM_BANK1/A9: U21.A18 (A9), U21.B18 (A9)
/RAM_BANK1/A10: U21.A19 (A10), U21.B19 (A10)
GND: C51.2, C52.2, C53.2, U21.A9 (GND), U21.A22 (GND), U21.A29 (DP), U21.B9 (GND), U21.B22 (GND), U21.B29 (DP); also elsewhere on the board

Parts of its further copies:
C21, C22, C23: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U20: SIMM-30x2; SIMM-30x2_VERT

Connections of its further copies:
+5V: C21.1, C22.1, C23.1, U20.A1 (VCC), U20.A24 (A11), U20.A28 (~CASP), U20.A30 (VCC), U20.B1 (VCC), U20.B24 (A11), U20.B28 (~CASP), U20.B30 (VCC); also elsewhere on the board
/CPU_A0: U20.A4 (A0), U20.B4 (A0); also elsewhere on the board
/CPU_A1: U20.A5 (A1), U20.B5 (A1); also elsewhere on the board
/CPU_A2: U20.A7 (A2), U20.B7 (A2); also elsewhere on the board
/CPU_A3: U20.A8 (A3), U20.B8 (A3); also elsewhere on the board
/CPU_A4: U20.A11 (A4), U20.B11 (A4); also elsewhere on the board
/CPU_A5: U20.A12 (A5), U20.B12 (A5); also elsewhere on the board
/CPU_A6: U20.A14 (A6), U20.B14 (A6); also elsewhere on the board
/CPU_A7: U20.A15 (A7), U20.B15 (A7); also elsewhere on the board
/CPU_A8: U20.A17 (A8), U20.B17 (A8); also elsewhere on the board
/CPU_A9: U20.A18 (A9), U20.B18 (A9); also elsewhere on the board
/CPU_A10: U20.A19 (A10), U20.B19 (A10); also elsewhere on the board
/CPU_D0: U20.A20 (DQ5), U20.B20 (DQ5); also elsewhere on the board
/CPU_D1: U20.A23 (DQ6), U20.B23 (DQ6); also elsewhere on the board
/CPU_D2: U20.A25 (DQ7), U20.B25 (DQ7); also elsewhere on the board
/CPU_D3: U20.A16 (DQ4), U20.B16 (DQ4); also elsewhere on the board
/CPU_D4: U20.A13 (DQ3), U20.B13 (DQ3); also elsewhere on the board
/CPU_D5: U20.A10 (DQ2), U20.B10 (DQ2); also elsewhere on the board
/CPU_D6: U20.A6 (DQ1), U20.B6 (DQ1); also elsewhere on the board
/CPU_D7: U20.A3 (DQ0), U20.B3 (DQ0); also elsewhere on the board
/CPU_~CAS_0: U20.B2 (~CAS); also elsewhere on the board
/CPU_~CAS_1: U20.A2 (~CAS); also elsewhere on the board
/CPU_~RAS_A: U20.A27 (~RAS), U20.B27 (~RAS); also elsewhere on the board
/CPU_~WE: U20.A21 (~WE), U20.B21 (~WE); also elsewhere on the board
GND: C21.2, C22.2, C23.2, U20.A9 (GND), U20.A22 (GND), U20.A29 (DP), U20.B9 (GND), U20.B22 (GND), U20.B29 (DP); also elsewhere on the board

Notes on the sheet:
Part numbers for sockets: Molex 15-46-0330 (dual) Berg 87731-102 (dual) Autotek SMV2030-6 (dual) ???? HWS9594 (dual) ???? HWS5040 (single) ???? HWS4323 (single, plastic) AdamTech SIMM-130-VTL (single) AMP 821876-2 (single) AMP 821885-2 (dual)
DRAM: There's one FPM DRAM from ISSI still in production: IS41LV16105D. This is a 1Mx16bit (3.3V) part. To mount it on a SIMM, one would need to: - Implement level-shifters - Add a 3.3V LDO - Add a single-bit flop to capture A10 on falling edge of RAS - Add a demux to select LCAS/HCAS based on capt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
SIMM socket source: https://www.peconnectors.com/sockets-pga-cpu-and-memory/hws9594/

Parts:
C46, C49, C74: 100uF; CP_Radial_D5.0mm_P2.00mm
CMC5, CMC6: L_Ferrite_Coupled_Small; SCM2012FS
FB15, FB16: FerriteBead_Small; L_Axial_L7.0mm_D3.3mm_P2.54mm_Vertical_Fastron_MICC
J7: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J16: USB_A_Stacked; GCT_USB1035-XX-X-X-X-B_REVE

Connections:
+5V: C74.1, FB15.1, FB16.1, J7.1; also elsewhere on the board
/MIO/USB_A_D+: CMC5.1; also elsewhere on the board
/MIO/USB_A_D-: CMC5.4; also elsewhere on the board
/MIO/USB_B_D+: CMC6.1; also elsewhere on the board
/MIO/USB_B_D-: CMC6.4; also elsewhere on the board
/MIO/USB_C_D+: J7.5; also elsewhere on the board
/MIO/USB_C_D-: J7.3; also elsewhere on the board
GND: C46.2, C49.2, C74.2, J7.7, J16.4 (GND1), J16.8 (GND2), J16.9 (Shield); also elsewhere on the board
unnamed: CMC5.2, J16.3 (D1+)
unnamed: CMC5.3, J16.2 (D1-)
unnamed: CMC6.2, J16.7 (D2+)
unnamed: CMC6.3, J16.6 (D2-)
unnamed: C46.1, FB15.2, J16.1 (VBUS1)
unnamed: C49.1, FB16.2, J16.5 (VBUS2)
